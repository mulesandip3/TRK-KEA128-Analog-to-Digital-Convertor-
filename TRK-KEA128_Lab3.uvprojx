# Keil uVision project TRK-KEA128_Lab3.uvprojx, settings and files
target TRK-KEA128_Lab3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: SKEAZ128xxx4 Freescale
  pack: Keil.Kinetis_KEAxx_DFP.1.2.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TRK-KEA128_Lab3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Headers
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Sources
    ./Sources/: ADC.c CLK.c main.c lcd.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
